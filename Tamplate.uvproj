# Keil uVision project Tamplate.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Tamplate +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\工程;.\ADC;.\LCD1602;.\SYS;.\USART
  group Source Group 1
    ./: main.c
  group SYS
    ./SYS/: delay.c GPIO.c
  group USART
    ./USART/: USART1.C
  group ADC
    ./ADC/: ADC.c
  group LCD1602
    ./LCD1602/: LCD1602.c
